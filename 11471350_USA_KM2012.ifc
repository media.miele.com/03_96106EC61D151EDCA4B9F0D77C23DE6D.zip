Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-02-15T11:56:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 15 11:56:14 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\1cba25d6-698f-4546-9aa1-b7133be1aecd\e4c1fa59-9a58-4e39-ae98-7e429758b040\ifc * Database version: 5507 * Database creation date: Tue Feb 15 11:56:13 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 15 11:56:13 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 15 11:56:13 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11471350_USA_KM2012:26201250_USA_11471350_KM2012, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 26201250_USA_11471350_KM2012
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26201250_USA_11471350_KM2012
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_Cast, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Gas, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_356410
Description: Flow; FlowDirection: SOURCEANDSINK
